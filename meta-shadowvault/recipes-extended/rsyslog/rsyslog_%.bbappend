# The audit log is a file source, so ensure the imfile input module is built.
PACKAGECONFIG:append = " imfile"
