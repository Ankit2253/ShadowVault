FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://audit.cfg"
